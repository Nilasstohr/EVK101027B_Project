<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\EVK101027B_Boot.ewp</path>
  </project><project>
    <path>$WS_DIR$\Appli\EVK101027B_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
