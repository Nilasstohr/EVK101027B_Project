# IAR project EVK101027B_Appli.ewp, settings and files
configuration EVK101027B_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../../Appli/Core/Inc; ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Appli/USB_DEVICE/App; ../../Appli/USB_DEVICE/Target; ../../Drivers/Vendor/Board/SE21229/Config; ../../Drivers/Vendor/Device; ../../Drivers/Vendor/Driver; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../Appli/Middlewares/ST/touchgfx/framework/include; ../../Appli/TouchGFX/generated/fonts/include; ../../Appli/TouchGFX/generated/images/include; ../../Appli/TouchGFX/generated/videos/include; ../../Appli/TouchGFX/generated/texts/include; ../../Appli/TouchGFX/generated/gui_generated/include; ../../Appli/TouchGFX/gui/include; ..\..\Appli\Middlewares\ST\touchgfx\framework\include\platform\core; ../../Appli/LWIP/App; ../../Appli/LWIP/Target; ../../Middlewares/Third_Party/LwIP/src/include; ../../Middlewares/Third_Party/LwIP/system; ../../Middlewares/Third_Party/LwIP/src/include; ../../Middlewares/Third_Party/LwIP/system; ../../Drivers/BSP/Components/lan8742; ../../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../../Middlewares/Third_Party/LwIP/src/include/lwip; ../../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../../Middlewares/Third_Party/LwIP/src/include/netif; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../../Middlewares/Third_Party/LwIP/system/arch; ../../Appli/FATFS/Target; ../../Appli/FATFS/App; ../../Middlewares/Third_Party/FatFs/source; ../../Middlewares/Third_Party/FatFs/source/drivers/sd; ../../Middlewares/Third_Party/FatFs/source/drivers/template; ..\..\Appli\ETHERNET_IF\App\tcpecho; ..\..\Appli\ETHERNET_IF\Target; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../Appli/Core/Inc; ../../Appli/FATFS/Target; ../../Appli/FATFS/App; ../../Appli/LWIP/App; ../../Appli/LWIP/Target; ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Appli/USB_DEVICE/App; ../../Appli/USB_DEVICE/Target; ../../Drivers/Vendor/Board/SE21229/Config; ../../Drivers/Vendor/Device; ../../Drivers/Vendor/Driver; ../../Appli/ETHERNET_IF/App/tcpecho; ../../Appli/ETHERNET_IF/Target; ../../Middlewares/Third_Party/LwIP/src/include; ../../Middlewares/Third_Party/LwIP/system; ../../Middlewares/Third_Party/LwIP/src/include; ../../Middlewares/Third_Party/LwIP/system; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Middlewares/Third_Party/FatFs/source; ../../Middlewares/Third_Party/FatFs/source/drivers/sd; ../../Middlewares/Third_Party/FatFs/source/drivers/template; ../../Drivers/BSP/Components/lan8742; ../../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Middlewares/Third_Party/LwIP/src/include/lwip; ../../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../../Middlewares/Third_Party/LwIP/src/include/netif; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../../Middlewares/Third_Party/LwIP/system/arch; ../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: EVK101027B_Appli.hex
  ILINK.IlinkOutputFile: EVK101027B_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkAdditionalLibs: ../../Appli/Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR9.x/touchgfx_core.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m7/IAR8.x/nemagfx_core_release.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m7/IAR8.x/touchgfx_nema_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma2d.c fdcan.c flash.c gpu2d.c hpdma.c i2c.c icache.c jpeg.c ltdc.c rtc.c sdmmc.c tim.c usart.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c
  group Application/User/Appli/FATFS/App
    ../../Appli/FATFS/App/: fatfs.c
  group Application/User/Appli/LWIP/App
    ../../Appli/LWIP/App/: lwip.c
  group Application/User/Appli/LWIP/Target
    ../../Appli/LWIP/Target/: ethernetif.c
  group Application/User/Appli/TouchGFX/App
    ../../Appli/TouchGFX/App/: app_touchgfx.c
  group Application/User/Appli/TouchGFX/target
    ../../Appli/TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/Appli/TouchGFX/target/generated
    ../../Appli/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp nema_hal.c
  group Application/User/Appli/USB_DEVICE/App
    ../../Appli/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/Appli/USB_DEVICE/Target
    ../../Appli/USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Drivers/Vendor
    ../../Drivers/Vendor/Board/SE21229/Config/: edt_board_config.c se21229_sys_conf.h
    ../../Drivers/Vendor/Driver/: edt_bsp_backlight.c edt_bsp_can.c edt_bsp_ctp.c edt_bsp_i2c.c edt_bsp_io.c edt_bsp_lcd.c edt_bsp_uart.c
  group Drivers/Vendor/Components
    ../../Drivers/Vendor/Device/ctp/: ILI2511v6.c
    ../../Drivers/Vendor/Device/eeprom/: AT24MAC402.c
  group Drivers/Vendor/ETHERNET_IF
    ../../Appli/ETHERNET_IF/App/tcpecho/: tcp_client.c tcp_server.c
    ../../Appli/ETHERNET_IF/Target/: app_ethernet.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_eth.c stm32h7rsxx_hal_eth_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_fdcan.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c
  group generated/fonts
    ../../Appli/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp CompressedFontCache.cpp CompressedUnmappedFontCache.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp VectorFontRendererBuffers.cpp
  group generated/gui_generated/common
    ../../Appli/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group generated/gui_generated/screen1_screen
    ../../Appli/TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group generated/images
    ../../Appli/TouchGFX/generated/images/src/: BitmapDatabase.cpp SVGDatabase.cpp
  group generated/images/__generated
    ../../Appli/TouchGFX/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp
  group generated/texts
    ../../Appli/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gui/common
    ../../Appli/TouchGFX/gui/src/common/: FrontendApplication.cpp
  group gui/model
    ../../Appli/TouchGFX/gui/src/model/: Model.cpp
  group gui/screen1_screen
    ../../Appli/TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c mpu_wrappers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP
    ../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffsystem_cmsis_os.c ffunicode.c
    ../../Middlewares/Third_Party/FatFs/source/drivers/sd/: sd_diskio_dma_rtos.c
  group Middlewares/STM32_USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
